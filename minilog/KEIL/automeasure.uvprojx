# Keil uVision project automeasure.uvprojx, settings and files
target GPIO_OutputInput (5060020::V5.06 (build 20)::ARMCC)
  device: M0516LBN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.0.9
  cpu: IROM(0x00000000,0x10000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: automeasure +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 wLevel=2
  c include: ..\..\Library\Device\Nuvoton\M051Series\Include;..\..\Library\CMSIS\Include;..\..\Library\StdDriver\inc
  asm include: ..\KEIL
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_M051Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../Library/Device/Nuvoton/M051Series/Source/: system_M051Series.c
    ../../Library/Device/Nuvoton/M051Series/Source/ARM/: startup_M051Series.s
  group User
    ../: main.c
  group Library
    ../../Library/StdDriver/src/: retarget.c gpio.c uart.c clk.c sys.c timer.c i2c.c adc.c
